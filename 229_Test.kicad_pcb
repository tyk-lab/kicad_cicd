# Repository tyk-lab/kicad_cicd

File README.md:

# 229测试板 KiCad项目

这是一个使用KiCad设计的PCB项目，包含自动化CI/CD流程。

<!-- BUILD_STATUS_START -->
## 📊 最新构建状态

**构建 #28** | **状态: ✗ 失败** | **时间: 2025-11-06 23:23:51 北京时间**

<details>
<summary>📋 详细报告</summary>

### ERC 检查
- **状态**: PASSED
- **错误**: 0 个
- **警告**: 0 个

### DRC 检查
- **状态**: FAILED
- **错误**: 12 个
- **警告**: 18 个

</details>

<!-- BUILD_STATUS_END -->

## 项目概述

- **项目名称**: 229测试板
- **KiCad版本**: 7.0+
- **PCB层数**: 2层

## 🚀 自动化构建

每次推送到主分支时，CI/CD 会自动执行以下操作：

### 质量检查
- ✅ **ERC检查** - 电气规则检查（区分错误/警告）
- ✅ **DRC检查** - 设计规则检查（区分错误/警告）
- ✅ **智能判断** - 只有错误才会导致构建失败

### 文件导出
- ✅ **原理图PDF** - 完整电路图文档
- ✅ **BOM清单** - CSV格式物料清单
- ✅ **Gerber文件** - 生产制造文件包
- ✅ **PCB图像** - SVG格式正反面预览
- ✅ **3D模型** - STEP格式（可选）

### 自动发布
- 📦 **构建产物** - 自动上传到 Artifacts
- 🏷️ **版本发布** - 自动创建 GitHub Release
- 📊 **状态同步** - 自动更新 README 徽章

## 🔧 技术特点

- **快速启动** - KiCad 缓存机制，30秒启动
- **智能检查** - 区分错误和警告，精准判断构建状态
- **自动清理** - 失败文件自动删除，避免误导
- **实时状态** - README 徽章实时显示构建结果
- **双平台支持** - GitHub Actions + GitLab CI/CD

## 最新构建输出

### PCB预览

### 下载文件

访问 [Releases页面](https://github.com/YOUR_USERNAME/YOUR_REPO/releases/latest) 下载最新的构建输出：

- 📄 [原理图PDF](https://github.com/YOUR_USERNAME/YOUR_REPO/releases/latest/download/229_Test-Schematic.pdf)
- 📋 [BOM清单](https://github.com/YOUR_USERNAME/YOUR_REPO/releases/latest/download/229_Test-BOM.csv)
- 📦 [Gerber文件](https://github.com/YOUR_USERNAME/YOUR_REPO/releases/latest/download/229_Test-Gerber.zip)
- 🖼️ [PCB正面图](https://github.com/YOUR_USERNAME/YOUR_REPO/releases/latest/download/229_Test-PCB-Front.svg)
- 🖼️ [PCB背面图](https://github.com/YOUR_USERNAME/YOUR_REPO/releases/latest/download/229_Test-PCB-Back.svg)

## 项目结构

```
.
├── 229_Test.kicad_pro      # KiCad项目文件
├── 229_Test.kicad_sch      # 原理图文件
├── 229_Test.kicad_pcb      # PCB文件
├── GERBER/                 # Gerber输出目录
└── .github/
    └── workflows/
        └── kicad-ci.yml    # CI/CD配置
```

## 本地开发

### 前置要求

- KiCad 7.0或更高版本
- Git

### 克隆项目

```bash
git clone https://github.com/YOUR_USERNAME/YOUR_REPO.git
cd YOUR_REPO
```

### 打开项目

使用KiCad打开 `229_Test.kicad_pro` 文件。

## 手动触发构建

1. 访问项目的 [Actions页面](https://github.com/YOUR_USERNAME/YOUR_REPO/actions)
2. 选择 "KiCad CI/CD" 工作流
3. 点击 "Run workflow" 按钮
4. 选择分支并点击 "Run workflow"

## 📋 检查报告

每次构建都会生成详细的检查报告：

### 报告文件
- 📄 **ERC报告**: `outputs/erc_report.json` - 电气规则检查详情
- 📄 **DRC报告**: `outputs/drc_report.json` - 设计规则检查详情
- 📄 **构建摘要**: `outputs/build_summary.md` - 完整构建报告

### 查看方式
1. **Artifacts** - GitHub Actions 页面下载完整输出
2. **Release** - 每次发布包含所有报告文件
3. **README** - 顶部徽章显示实时状态

### 状态说明
- 🟢 **通过** - 无错误无警告
- 🟡 **警告** - 有警告但无错误（构建成功）
- 🔴 **失败** - 有错误（构建失败）

## 🛠️ 本地使用工具

### 快速开始
```bash
# 运行完整导出
python3 scripts/kicad_export.py 229_Test.kicad_pro

# 只运行检查
python3 scripts/kicad_export.py 229_Test.kicad_pro --skip-exports

# 指定输出目录
python3 scripts/kicad_export.py 229_Test.kicad_pro -o build
```

### 更多选项
查看 `scripts/README.md` 了解完整功能和用法。

## 📚 文档

- 📖 [工具使用指南](scripts/README.md) - Python脚本详细说明
- ⚡ [CI/CD触发策略](docs/CI-CD-Trigger-Strategy.md) - 触发时机和执行策略详解 ⭐
- 🔀 [CI/CD平台对比](docs/CI-CD-Comparison.md) - GitHub vs GitLab
- 🔄 [README自动更新](docs/README-Auto-Update.md) - 状态徽章配置
- 📋 [完整系统概述](docs/SUMMARY.md) - 系统架构和技术实现

## 许可证

请在此添加您的许可证信息。

## 贡献

欢迎提交Issue和Pull Request！

---

*此README由GitHub Actions自动更新*

## KiCad design 229_Test.kicad_pcb

Parts:
C1: 1u; C_0603_1608Metric; MFG# C1608X7R1C105KT000N; LCSC C76617
C2: 22n; C_0402_1005Metric; LCSC C107026
C3: 2u2; C_0603_1608Metric; MFG# GRM188R71A225KE15D; LCSC C86018
C4: 100u/25V; CP_Radial_D6.3mm_P2.50mm; MFG# 25ZLG100MEFCT16.3X11; LCSC C472886
C5: 10u; C_1206_3216Metric; MFG# CL31B106KBHNNNE; LCSC C89632
C6, C7: 12pF; C_0603_1608Metric; MFG# CL10C120JB8NNNC; LCSC# C38523
C8, C10, C12, C14, C17, C18, C19, C20, C22, C23, C24, C25, C26, C27, C28, C30: 100n; C_0603_1608Metric; MFG# C83054; LCSC C83054
C9: 4u7; C_0603_1608Metric; MFG# 0603B475K100NT; LCSC C108342
C11, C13, C15, C29: 2u2; C_0603_1608Metric; MFG# 0603B225K250NT; LCSC C99228
C16, C21: 1u; C_0603_1608Metric; MFG# CL10B105KA8NNNC; LCSC C29936
C31, C32: 100n; C_0603_1608Metric
D1, D2, D3, D5: red; LED_0603_1608Metric; LCSC C434419
D4: 15V; D_SOD-123; LCSC C177014
D6: red; LED_0603_1608Metric
D7: CUS10S30,H3F; D_SOD-323_HandSoldering; LCSC C146335
D8: red,NC; LED_0603_1608Metric
FB1: 600Z; L_0805_2012Metric; LCSC C21286
J1: MAX128H-5.08-02P; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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; LCSC C161869
J2: PZ254V-11-04P; PinSocket_1x04_P2.54mm_Vertical
J3: MAX128H-3.81-02P; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical; LCSC C161869
J4, J6: MAX128H-3.81-02P; PinHeader_1x02_P2.54mm_Vertical; LCSC C161869
J5: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12; LCSC C136423
L1: 10uH; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder; LCSC C281113
PS1: K7805-3AR3; R7450P; Manufacturer_Part_Number R-745.0P; Mouser Part Number 919-R-745.0P
Q1: SUD50P06-15-GE3; TO-252-2; MFG# SUD50P06-15-GE3; LCSC# C141584
R1: 10k; R_0603_1608Metric; MFG# WR06X103JTL; LCSC# C384294
R2: 1k; R_0603_1608Metric; LCSC C115325
R3, R15: 1k; R_0603_1608Metric; LCSC C14676
R4, R6, R10, R12: 10k; R_0603_1608Metric; LCSC C384294
R5: 100k; R_0603_1608Metric; LCSC C14675
R7: 361k; R_0603_1608Metric; LCSC C2108324
R8: 100k; R_0603_1608Metric; LCSC C15458
R9: 100k; R_0603_1608Metric; LCSC C25803
R16: 1K; R_0603_1608Metric
R17: 0.01R; R_2512_6332Metric
R18, R19: 10R; R_0603_1608Metric
R20, R21: 5k1; R_0603_1608Metric; LCSC C23186
R22: 10K,NC; R_0603_1608Metric
R23: 1K,NC; R_0603_1608Metric
SW1: Reset; SW_SPST_B3U-1000P; LCSC C231329
SW2: BOOT0; SW_SPST_B3U-1000P; LCSC C231329
U1: AP2112K-3.3V/AP2127K-3.3V; SOT-23-5; MFG# AP2112K-3.3TRG1; LCSC# C51118/C156285
U2: STM32H743ZIT6; LQFP-144_20x20mm_P0.5mm; LCSC C730146
U3: USBLC6-2SC6; SOT-23-6; LCSC C7519
U4: INA229; VSSOP-10_3x3mm_P0.5mm
Y1: 25MHz; Crystal_SMD_Abracon_ABM8G-4Pin_3.2x2.5mm; LCSC C91750

Connections:
3V3_CS: U2.69 (PB10)
5V_CS: U2.68 (PE15)
12V_CS: U2.65 (PE12)
24V_CS: U2.63 (PE10)
+3.3VA: C15.1, C17.1, C29.1, C30.1, L1.2, U2.32 (VREF+), U2.33 (VDDA)
+3V3: C3.1, C9.1, C10.1, C12.1, C14.1, C16.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, J2.1, J6.1, L1.1, R3.2, R4.1, R6.1, R9.2, SW2.1, U1.5 (OUT), U2.6 (VBAT), U2.17 (VDD), U2.30 (VDD), U2.39 (VDD), U2.52 (VDD), U2.62 (VDD), U2.72 (VDD), U2.84 (VDD), U2.95 (VDDUSB), U2.108 (VDD), U2.121 (VDD), U2.131 (VDD), U2.143 (PDR_ON), U2.144 (VDD)
+5V: C1.1, C4.1, D7.1 (K), PS1.9 (VOUT_1), PS1.10 (VOUT_2), PS1.11 (VOUT_3), R2.2, R7.2, U1.1 (IN), U1.3 (EN)
/3V3: C32.1, J6.2, R16.2, R22.2, R23.1, U4.6 (VS)
A0: U2.98 (PC8)
A1: U2.96 (PC6)
A2: U2.85 (PD14)
A3: U2.81 (PD12)
A4: U2.75 (PB14)
A5: U2.70 (PB11)
A6: U2.66 (PE13)
A7: U2.60 (PE9)
ALERT0: U2.93 (PG8)
ALERT1: U2.92 (PG7)
ALERT2: D8.1 (K), R22.1, U2.91 (PG6), U4.3 (~ALERT)
ALERT_3V3: U2.90 (PG5)
ALERT_5V: U2.89 (PG4)
ALERT_12V: U2.88 (PG3)
ALERT_24V: U2.87 (PG2)
B0: U2.99 (PC9)
B1: U2.97 (PC7)
B2: U2.86 (PD15)
B3: U2.82 (PD13)
B4: U2.76 (PB15)
B5: U2.74 (PB13)
B6: U2.67 (PE14)
B7: U2.64 (PE11)
BOOT0: R10.1, SW2.2, U2.138 (BOOT0)
CAN_RX: U2.139 (PB8)
CAN_TX: U2.140 (PB9)
CS_HE0: U2.44 (PC4)
CS_HE1: U2.45 (PC5)
CS_HE2: U2.40 (PA4), U4.1 (CS)
DIAG_DRV8: U2.122 (PD6)
DIR_DRV8: U2.117 (PD3)
EN_DRV8: U2.123 (PD7)
Endstop0: U2.27 (PC1)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, D1.1 (K), D2.1 (K), D3.1 (K), FB1.2, J1.2, J2.3, J5.A1 (GND), J5.A12 (GND), J5.B1 (GND), J5.B12 (GND), PS1.5 (GND_1), PS1.6 (GND_2), PS1.7 (GND_3), PS1.8 (GND_4), R5.2, R8.1, R10.2, R12.1, R20.2, R21.2, SW1.1, U1.2 (GND), U2.16 (VSS), U2.31 (VSSA), U2.38 (VSS), U2.51 (VSS), U2.61 (VSS), U2.83 (VSS), U2.94 (VSS), U2.107 (VSS), U2.120 (VSS), U2.130 (VSS), U3.2 (GND), Y1.2, Y1.4
HEATER_TH0: U2.110 (PA15)
Heater2+: J4.1, R17.2, R18.1, U4.8 (VBUS)
Heater2-: C32.2, D5.1 (K), D6.1 (K), J3.2, J4.2, U4.7 (GND)
IN2-: J3.1, R15.2, R17.1, R19.1
LED0_INT: U2.56 (PG0)
LED1_INT: U2.80 (PD11)
LED2_INT: U2.79 (PD10)
LED3_INT: U2.78 (PD9)
LED4_INT: U2.77 (PD8)
LED5_INT: U2.73 (PB12)
MCU_TH0: U2.34 (PA0)
MCU_WLED: U2.46 (PB0)
unnamed: D1.2 (A), R1.1
unnamed: D2.2 (A), R2.1
unnamed: D3.2 (A), R3.1
unnamed: D4.2 (A), Q1.1 (G), R5.1
unnamed: D5.2 (A), R15.1
unnamed: D6.2 (A), R16.1
unnamed: D7.2 (A), J5.A4 (VBUS), J5.A9 (VBUS), J5.B4 (VBUS), J5.B9 (VBUS), U3.5 (VBUS)
unnamed: D8.2 (A), R23.2
unnamed: J1.1, Q1.2 (D)
unnamed: J5.A5 (CC1), R20.1
unnamed: J5.B5 (CC2), R21.1
unnamed: J5.A6 (D+), J5.B6 (D+), U3.6 (I/O1)
unnamed: J5.A7 (D-), J5.B7 (D-), U3.4 (I/O2)
unnamed: FB1.1, J5.S1 (SHIELD)
unnamed: PS1.12 (VADJ), R7.1, R8.2
unnamed: C2.1, U1.4 (BP)
unnamed: R12.2, U2.48 (PB2)
unnamed: C6.1, U2.23 (PH0), Y1.1
unnamed: C7.1, U2.24 (PH1), Y1.3
unnamed: C11.1, U2.71 (VCAP_1)
unnamed: C13.1, U2.106 (VCAP_2)
unnamed: C31.1, R18.2, U4.10 (IN+)
unnamed: C31.2, R19.2, U4.9 (IN-)
PWM_Hotend: U2.125 (PG10)
SPI1_MISO: U2.42 (PA6), U4.4 (MISO)
SPI1_MOSI: U2.43 (PA7), U4.2 (MOSI)
SPI1_SCK: U2.41 (PA5), U4.5 (SCLK)
STEP_DRV8: U2.118 (PD4)
SWCLK: J2.4, R4.2, U2.109 (PA14)
SWDIO: J2.2, R6.2, U2.105 (PA13)
TACH0: U2.7 (PC13)
TACH1: U2.8 (PC14)
TACH2: U2.9 (PC15)
TACH3: U2.10 (PF0)
TACH4: U2.11 (PF1)
TACH5: U2.12 (PF2)
TH0: U2.35 (PA1)
TH1: U2.36 (PA2)
TH2: U2.37 (PA3)
UART_DRV8: U2.119 (PD5)
USB_N: U2.103 (PA11), U3.3 (I/O2)
USB_P: U2.104 (PA12), U3.1 (I/O1)
VDD: C5.1, D4.1 (K), PS1.2 (VIN_1), PS1.3 (VIN_2), PS1.4 (VIN_3), Q1.3 (S), R1.2
~RESET: C8.1, R9.1, SW1.2, U2.25 (NRST)

Notes on the sheet:
Board supply
HEATER3 INA229
复位改按键
MCU
PG6
PA4
USB
加热头接口
PWR IN
24V电压输入
SWD

Board: 2 copper layers, 80.0 x 50.0 mm, 77 parts (0 on the bottom side), 43 nets.

## Commit log

2025-10-31 初始化工程
2025-10-31 添加 KiCad CI/CD 工作流、README 并更新 .gitignore
    - 新增 .github/workflows/kicad-ci.yml：在 CI 中运行 ERC/DRC，导出原理图 PDF、BOM、Gerber、SVG/3D，并上传 artifacts / 创建 Release
    - 新增 README.md：项目说明、构建输出与使用说明
    - 更新 .gitignore：忽略构建产物、临时文件与常见 IDE/OS 文件
2025-10-31 将 GitHub Actions 运行器固定为 ubuntu-22.04，安装 KiCad 时添加 --fix-broken 和 --no-install-recommends 以避免依赖冲突
2025-10-31 切换 KiCad CI 到 Windows runner 并迁移到 PowerShell
    - 将 runs-on 改为 windows-latest
    - 使用 Chocolatey 安装 KiCad 9.0.6，并将安装目录追加到 GITHUB_PATH
    - 将各步骤 shell 切换为 PowerShell，改写文件检查（Test-Path/Get-Content）、目录创建（New-Item）、压缩（Compress-Archive）等命令
    - 将 kicad-cli 命令行适配 PowerShell 行续接符，3D 导出改为 try/catch 以避免失败中断工作流
    - 使用 PowerShell 生成 build_summary.md（含 UTC 时间）
2025-10-31 增强 Windows KiCad CI：添加安装验证、改用 kicad-cli 完整路径、增强日志与错误处理，移除写入 GITHUB_PATH 的操作
2025-10-31 规范 PowerShell 日志输出：移除 emoji 与特殊符号，统一换行与提示文本
    - 从 .github/workflows/kicad-ci.yml 中移除 Write-Host 的 emoji/特殊字符（如 🔍、✅、❌、📄 等）
    - 将带 `\`n` 的内联换行替换为显式的 Write-Host ""，使日志输出更一致可读
    - 统一并简化 Verify、ERC、DRC、Export PDF/BOM/Gerber/Images 等步骤的提示文本
    - 仅调整日志/输出文本格式，无功能性行为变更
2025-10-31 增强 Windows KiCad CI：添加安装缓存与按需安装，安装 vcredist 并配置 PATH；增强安装/验证日志、ERC/DRC 运行的鲁棒性与输出（打印 DLL 列表、捕获输出、生成空报告以避免失败）
2025-10-31 增强 Windows KiCad CI：添加额外依赖安装与运行时诊断输出
    - 在 .github/workflows/kicad-ci.yml 中新增“Install additional dependencies”步骤，使用 choco 安装 dotnetfx、opengl、python，确保运行时依赖可用。
    - 新增“Show environment and DLLs”步骤，打印 PATH、KiCad bin 下的 DLL 列表并显示 kicad-cli 版本，便于定位环境问题。
    - 在 ERC 检查的崩溃与异常处理分支中补充打印 PATH 与 KiCad DLL 列表，增强故障诊断信息，帮助识别缺失依赖或访问冲突。
2025-10-31 增强 Windows KiCad CI：改进 PCB 图像与 3D 导出流程，捕获并打印命令输出、基于输出文件判断成功并优化错误处理
2025-10-31 增强 Windows KiCad CI：启用并健壮化 DRC 检查步骤，替换跳过占位符为实际运行 kicad-cli pcb drc，使用 kicad-cli 全路径、检查 PCB 文件存在、捕获并报告退出码，输出 drc_report.json 内容，若未生成则创建空报告以避免后续失败
2025-10-31 改进 KiCad CI：统一输出方式并稳健化 ERC/DRC 检查
    - 将 echo >> $env:GITHUB_OUTPUT 替换为 Out-File 写入，修正 PowerShell 输出兼容性
    - 统一 ERC/DRC 调用为使用 kicad-cli ... --exit-code-violations --format json，并捕获 $LASTEXITCODE 以判断结果
    - 移除冗余 try/catch 与部分诊断打印，改为根据退出码打印通过/警告信息
    - 在未生成报告时将作业标记为失败（exit 1），避免生成空报告掩盖问题
    - 将 ERC/DRC 的执行状态（status, violations）写入 GITHUB_OUTPUT，且为两步添加 id 以便引用
    - 在构建摘要中加入 ERC/DRC 状态显示
2025-10-31 增强 Windows KiCad CI：统一日志前缀并移除构建摘要中的 emoji
    - 将安装与检查输出中的符号（✓/✗/⚠）替换为明确文本前缀（如 "ERROR:"、"WARNING:"），统一日志风格
    - 在 outputs/build_summary.md 中移除 ERC/DRC 与报告项的 emoji，改用纯文本描述，便于自动化处理与解析
2025-10-31 清理 KiCad CI：移除环境与 DLL 诊断步骤，调整 PCB 图像导出结束行为以确保正确退出
2025-10-31 增强 KiCad CI：加入 ERC 详细诊断，移除重复安装验证，整理 Release 流程
    - 在 workflow 顶部添加 permissions: contents: write，明确 GitHub Token 权限
    - 删除重复的 Verify KiCad installation 步骤
    - 大幅增强 ERC 步骤：加入环境/文件/安装/版本/依赖/显示变量检查，打印 kicad-cli 信息、CLI 帮助，运行时捕获输出与计时，捕获异常并区分崩溃（0xC0000005），检查并打印 erc_report.json 内容，设置更详尽的输出状态变量
    - 准备 Release 文件步骤改为复制 outputs 到 release/，并包含 ERC/DRC 报告（如存在）
    - Create Release 改为上传 release/**/*，并设置 fail_on_unmatched_files:
2025-10-31 改进 KiCad CI：ERC 改为使用 --severity-all（移除 --verbose）；精简 release 打包逻辑只复制关键输出并改进日志与大小显示；新增结束时的 CI/CD 结果摘要输出步骤
2025-10-31 改进 KiCad CI：统一 CI 结果输出为英文并移除 emoji/特殊符号；修正文件大小计算（使用 1024 而非 1KB）并格式化发布文件列表输出
2025-10-31 改进 KiCad CI：切换到 Ubuntu runner 并将工作流从 Windows/PowerShell 迁移为 Linux/bash
    - 将 runs-on 改为 ubuntu-latest，统一使用 Linux 环境运行
    - 替换缓存路径与 key（Windows -> /usr/bin/kicad-cli、/usr/share/kicad；key 简化为 kicad-latest）
    - 安装逻辑改为通过 kicad 9.0 PPA + apt-get，移除 choco 与 Windows 依赖安装
    - 将所有步骤由 PowerShell 重写为 bash：检出、缓存检查、安装、ERC/DRC、导出（PDF/BOM/Gerber/SVG/STEP）、打包 ZIP、上传 artifacts 等
    - 精简并移除大量 Windows 专用诊断（DLL/环境变量/彩色输出等），保留必要的检查与 JSON 报告生成
    - ERC/DRC 调用保持 --severity-al
2025-10-31 改进 KiCad CI：固定 runner 为 ubuntu-22.04；修复构建摘要状态计算逻辑
    - 将 jobs.runs-on 从 ubuntu-latest 改为 ubuntu-22.04，确保运行环境一致
    - 修复 Update README with status 步骤中对 cache/ ERC/DRC 状态的赋值逻辑：
    使用 shell if 判断读取 steps 输出生成可读状态（避免在 run 脚本中使用复合 GitHub 表达式）
2025-10-31 改进 KiCad CI：优先使用 snap 安装并添加轻量级 apt 备选；更新缓存键并加入 /snap/kicad 路径，创建 kicad-cli 链接，优化安装验证与日志
2025-10-31 改进 KiCad CI：增强 snap 安装检测并改进 apt 回退逻辑
    - 调整 snap 安装流程，改为通用 snap install 并增强对 /snap/bin 下可执行名的检测（kicad-cli / kicad.kicad-cli）
    - 为可用 snap CLI 创建 /usr/bin/kicad-cli 符号链接并在成功安装时写入标记 (~/.kicad-installed)
    - 优化回退方案：从仅安装 kicad-cli 改为安装完整 kicad 包，改进日志与错误诊断
2025-10-31 改进 KiCad CI：新增 KiCad CLI 可用性验证并统一使用 KICAD_CLI 环境变量；规范导出步骤注释与输出提示
2025-11-03 简化 KiCad CI：移除大型工作流并引入可复用脚本与文档
    - 删除冗长的 .github/workflows/kicad-ci.yml（精简为脚本驱动的方案）
    - 新增 scripts/kicad_export.py：统一实现 ERC/DRC 检查、导出原理图 PDF、BOM、Gerber（并打包为 ZIP）、PCB SVG、3D STEP；自动检测 kicad CLI，输出详细日志与构建摘要，且通过退出码反映质量检查结果
    - 新增 scripts/README.md：说明脚本用法、参数、输出结构与 CI 集成建议
    目的：把复杂、难维护的 Actions 步骤迁移到可在本地/CI 复用的 Python 脚本中，简化 CI 配置并提升可维护性与可测试性
2025-11-03 新增 KiCad CI：添加简化的 GitHub Actions 工作流，支持 snap 优先安装并回退 apt、缓存安装标记、运行 Python 导出脚本、上传构建产物并创建 Release，最后输出构建摘要
2025-11-03 移除旧版 KiCad GitHub Actions 工作流（BASE / LOCAL / REMOTE）
    - 删除 .github/workflows/kicad-ci.yml.BASE.yml、.github/workflows/kicad-ci.yml.LOCAL.yml、.github/workflows/kicad-ci.yml.REMOTE.yml
    - 这些文件为早期/冗余的大型工作流实现，已由简化的可复用脚本与新的工作流/文档替代
    - 清理仓库，减少维护负担并统一 CI 配置
2025-11-03 改进 kicad_export.py：增强 3D STEP 导出鲁棒性并将其标记为可选，新增 custom_3d_path 参数
    - 在 KiCadExporter 构造函数增加 custom_3d_path 参数（预留用于自定义 3D 模型路径）
    - 用显式 subprocess.run 执行 3D STEP 导出，加入 KICAD_SKIP_ERRORS 环境以抑制 wxWidgets 输出并捕获超时/异常
    - 根据执行结果设置 results["exports"]["step_3d"]，导出失败或异常时记录为跳过，且不影响整体成功状态
    - 增强日志输出，显示执行命令与结果提示
    - 修改生成摘要逻辑：导出项加入必需/可选标记，3D STEP 标记为可选并在跳过时输出说明
2025-11-03 改进 kicad_export.py：过滤 wxWidgets 调试输出并改进 ERC/DRC 解析逻辑
    - 新增 _filter_wx_debug，用于清理 wxWidgets 的冗余调试信息，并在 _run_command 中使用，避免直接打印 stderr/退出码
    - 不再使用 --exit-code-violations，改为解析 ERC/DRC 生成的 JSON 报告
    - 按严重级别统计 violations（errors/warnings/exclusions），只有 error 计为 failed，warning 单独标记为 warning，passed/erro 状态更细化
    - 调整 _format_check_status 的输出文本以反映 errors/warnings/exclusions 信息
    - 保持 3D 导出为可选行为（导出失败不影响整体状态）
2025-11-03 改进 kicad CI 工作流：添加全局 env 并参数化项目名与输出目录
    - 新增 env: KICAD_PROJECT_NAME 与 OUTPUT_DIR
    - 将脚本调用、报告检查、Artifact 上传、Release 打包/路径及输出列表全部改为使用上述环境变量
    - 统一输出目录引用，避免硬编码项目名和 outputs 路径
2025-11-03 改进 kicad_export.py：在3D STEP导出失败或异常时清理不完整的 STEP 文件
2025-11-03 新增 scripts/update_readme.py：在 CI 中生成并更新 README 的构建状态区域；在 kicad-ci.yml 中集成 Update README 步骤并调整步骤编号；更新 README.md，添加构建状态占位区并修正工作流徽章链接
2025-11-03 docs: 更新构建状态 #24 [skip ci]
2025-11-03 新增 GitLab CI 配置，改进 GitHub Actions 工作流并补充文档与 README
    - 新增 .gitlab-ci.yml：完整的 GitLab 多阶段流水线（安装 KiCad、运行导出、更新 README、打包与创建 Release），包含缓存、Artifacts 过期策略与 MR 专用行为
    - 改进 .github/workflows/kicad-ci.yml：
    - 智能触发（paths / paths-ignore）与 workflow_dispatch 输入（skip_checks/skip_exports/create_release）
    - 使用全局 env（KICAD_PROJECT_NAME/OUTPUT_DIR），在步骤中传参并支持 PR 模式仅运行检查
    - 上传产物时添加 run_number 到名称并根据事件类型调整保留期，Update README 与 Create Release 增加条件判断
    - 优化脚
2025-11-03 ci: 修复 GitHub Actions/ GitLab CI 配置并新增修复说明
    - 修复 .github/workflows/kicad-ci.yml 中的缓存 key 引用（.yml 文件名）
    - 修正 workflow_dispatch inputs 的访问方式为 github.event.inputs，并统一布尔比较为 'true'
    - 修正 release 相关条件判断，移除不正确的 paths-ignore 配置
    - 修复 .gitlab-ci.yml：统一 artifacts 过期时间为 30 天，移除 rules 中嵌套 artifacts 与与 rules 冲突的 only 配置
    - 新增 docs/CI-CD-Fix-Summary.md，记录发现的问题与修复详情，方便后续验证
2025-11-03 docs: 更新构建状态 #26 [skip ci]
2025-11-03 scripts: update_readme.py：将构建时间戳从 UTC 改为北京时间（引入 timezone/timedelta）
2025-11-03 docs: 更新构建状态 #27 [skip ci]
2025-11-06 scripts: 为 3D STEP 导出添加额外 kicad-cli 参数 (--no-dnp, --drill-origin, --subst-models, --min-distance 0.01mm)
    增强 STEP 导出兼容性与精度，确保处理钻孔原点和替代模型，减少生成不完整 3D 模型的情况
2025-11-06 docs: 更新构建状态 #28 [skip ci]
